## drivers/soc/aspeed/rvas/Kconfig
```kconfig
menu "ASPEED RVAS drivers"

config AST_RVAS
	tristate "ASPEED RVAS driver"
	default n
	help
	  Driver for AST RVAS Engine

endmenu
```
